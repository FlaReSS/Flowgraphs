options:
  parameters:
    author: Stefano Speretta
    generate_options: qt_gui
    id: coherent_carrier_generation
    output_language: python
    title: Coherent Carrier Generation
  states: {}

blocks:
- name: S_N
  id: variable_qtgui_range
  parameters:
    label: S/N (dB)
    orient: Qt.Horizontal
    start: '-10'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: coherency
  id: variable_qtgui_chooser
  parameters:
    label: Coherency
    label0: Open Loop
    label1: Coherent
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    orient: Qt.Horizontal
    start: '-20e3'
    step: '100'
    stop: 20e3
    value: '15000'
  states: {}
- name: loop_filter_2nd_order
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '200'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.6'
  states: {}
- name: modulation_coeff_down
  id: variable_qtgui_range
  parameters:
    label: Downlink Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
    widget: counter
  states: {}
- name: modulation_coeff_up
  id: variable_qtgui_range
  parameters:
    label: Uplink Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 2.0**0.5 * 10**(-S_N/20)
    noise_type: analog.GR_GAUSSIAN
    seed: '123'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: modulation_coeff_down/2
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.8'
    init: '0'
    low: '.5'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: ecss_agc_xx_0
  id: ecss_agc_xx
  parameters:
    initial_gain: '1.0'
    maximum_gain: '65536.0'
    reference: '1.0'
    samp_rate: samp_rate
    settling_time: '10.0'
    type: float
  states: {}
- name: ecss_coherent_phase_modulator_0
  id: ecss_coherent_phase_modulator
  parameters:
    N: '38'
  states: {}
- name: ecss_gain_phase_accumulator_0
  id: ecss_gain_phase_accumulator
  parameters:
    downlink: coherency*240
    rst: 'False'
    uplink: '221'
  states: {}
- name: ecss_phase_converter_0
  id: ecss_phase_converter
  parameters:
    N: '38'
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '0'
    coefficients: loop_filter_2nd_order
    freq_central: frequency
    samp_rate: samp_rate
  states: {}
- name: ecss_signal_search_goertzel_0
  id: ecss_signal_search_goertzel
  parameters:
    average: 'False'
    bandwidth: '3000'
    enable: 'True'
    freq_central: frequency
    freq_cutoff: '100'
    samp_rate: samp_rate
    threshold: '10'
  states: {}
- name: ecss_threshold_to_message_0
  id: ecss_threshold_to_message
  parameters:
    init_state: 'False'
    lower_message: pmt.intern("UNLOCK")
    lower_threshold: '0.5'
    upper_message: pmt.intern("LOCK")
    upper_threshold: '0.8'
  states: {}
- name: flaress_add_0
  id: flaress_add
  parameters:
    num_inputs: '2'
    type: s64
    vlen: '1'
  states: {}
- name: flaress_float_to_int64_0
  id: flaress_float_to_int64
  parameters:
    scale: '1'
    vlen: '1'
  states: {}
- name: flaress_multiply_double_0
  id: flaress_multiply_double
  parameters:
    num_inputs: '2'
    type: s64
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: Input
    label2: Output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
    ymin: '-90'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '100e-6'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 70e6
    dev_args: '""'
    gain0: '10'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: '0'
    center_freq1: 70e6
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', ecss_signal_search_goertzel_0, '0']
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_2, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_float_2, '1', ecss_agc_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', ecss_phase_converter_0, '0']
- [blocks_threshold_ff_0, '0', flaress_float_to_int64_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [ecss_agc_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [ecss_coherent_phase_modulator_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_coherent_phase_modulator_0, '0', uhd_usrp_sink_0, '0']
- [ecss_gain_phase_accumulator_0, '0', flaress_add_0, '0']
- [ecss_phase_converter_0, '0', flaress_add_0, '1']
- [ecss_pll_0, '0', blocks_complex_to_float_2, '0']
- [ecss_pll_0, '1', blocks_null_sink_0_0, '0']
- [ecss_pll_0, '2', blocks_null_sink_0, '0']
- [ecss_pll_0, '3', flaress_multiply_double_0, '0']
- [ecss_signal_search_goertzel_0, '0', ecss_pll_0, '0']
- [ecss_threshold_to_message_0, threshold_msg, blocks_message_debug_0, print]
- [ecss_threshold_to_message_0, threshold_msg, ecss_signal_search_goertzel_0, lock_in]
- [flaress_add_0, '0', ecss_coherent_phase_modulator_0, '0']
- [flaress_float_to_int64_0, '0', flaress_multiply_double_0, '1']
- [flaress_multiply_double_0, '0', ecss_gain_phase_accumulator_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_threshold_ff_0, '0']
- [single_pole_iir_filter_xx_0, '0', ecss_threshold_to_message_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_null_sink_2, '0']
- [uhd_usrp_source_0, '1', blocks_add_xx_0, '0']

metadata:
  file_format: 1
