options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: flaress_modulation_test
    output_language: python
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: cof
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1)
    label: LPF cut-off frequency
    min_len: '50'
    orient: Qt.Horizontal
    start: '10.0'
    step: '100.0'
    stop: '10000.0'
    value: '10.0'
  states: {}
- name: n_bit
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: PLL N bits
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '4'
    step: '1'
    stop: '52'
    value: '38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: tw
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,2)
    label: LPF Transition Width
    min_len: '50'
    orient: Qt.Horizontal
    start: '10.0'
    step: '100.0'
    stop: '10000.0'
    value: '10'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/c/Users/amir/WSL/grc/FlowGraps/FlaReSS/files/modulated_signal_output
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/amir/WSL/grc/FlowGraps/FlaReSS/files/CADU.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/amir/WSL/grc/FlowGraps/FlaReSS/files/Convolutionally_encoded_CADU.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: ecss_coherent_phase_modulator_0
  id: ecss_coherent_phase_modulator
  parameters:
    N: n_bit
  states: {}
- name: ecss_modulator_0
  id: ecss_modulator
  parameters:
    bit_rate: bit_rate
    freq_sub: '16000'
    k: '7'
    num_taps: samp_rate/11
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    roll_off: '0.35'
    samp_rate: samp_rate
    sel_convolutional: '1'
    sel_encoder: '0'
    sel_srrc: '1'
    sine: 'True'
    state_start: '0'
  states: {}
- name: ecss_phase_converter_0
  id: ecss_phase_converter
  parameters:
    N: n_bit
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cof
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: tw
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024 '
    grid: 'True'
    gui_hint: (7,0,2,3)
    name: Output Signal Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (2,0,1,3)
    label1: ''
    name: Input
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (5,0,2,3)
    label1: ''
    name: Modulated Signal Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', ecss_modulator_0, '0']
- [ecss_coherent_phase_modulator_0, '0', blocks_file_sink_0, '0']
- [ecss_coherent_phase_modulator_0, '0', qtgui_freq_sink_x_0_0, '0']
- [ecss_modulator_0, '0', low_pass_filter_0, '0']
- [ecss_phase_converter_0, '0', ecss_coherent_phase_modulator_0, '0']
- [low_pass_filter_0, '0', ecss_phase_converter_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
