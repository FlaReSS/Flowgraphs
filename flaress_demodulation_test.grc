options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: flaress_demodulation_test
    output_language: python
  states: {}

blocks:
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,2)
    label: Frequency offset Channel
    min_len: '50'
    orient: Qt.Horizontal
    start: '0.0'
    step: '100'
    stop: '10000.0'
    value: '0.0'
  states: {}
- name: n_bit
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: PLL N bits
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '4'
    step: '1'
    stop: '52'
    value: '38'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1)
    label: Noise Channel
    min_len: '50'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.05'
    stop: '10.0'
    value: '0.0'
  states: {}
- name: order
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,0)
    label: PLL order
    num_opts: '2'
    option0: '2'
    option1: '3'
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: reset
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,1)
    label: Coherency Reset
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: second_order
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '100'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.6'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ss
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,2)
    label: Signal Search Enable
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/c/Users/amir/WSL/grc/FlowGraps/FlaReSS/files/Demodulated_data.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/stefanosperett/Documents/Research/FlaReSS/GitHub/Flowgraphs/sw150kHz_swr10kHz-s_tc4kbps_mi1.0.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: ecss_agc_xx_0
  id: ecss_agc_xx
  parameters:
    initial_gain: '1.0'
    maximum_gain: '65536.0'
    reference: '1.0'
    samp_rate: samp_rate
    settling_time: '10.0'
    type: complex
  states: {}
- name: ecss_demodulator_0
  id: ecss_demodulator
  parameters:
    cl_freq_sub: '16000'
    cl_loop_bandwidth: 6.28/100
    cl_order: '2'
    k: '8'
    samp_rate: samp_rate
    sel_costas: '1'
    sel_spl: '0'
    ss_constellation: digital.constellation_bpsk().base()
    ss_damping: '1.0'
    ss_interpolation: digital.IR_MMSE_8TAP
    ss_loop_bandwidth: '0.045'
    ss_max_dev: '1.5'
    ss_nfilter: '128'
    ss_out_ss: '1'
    ss_pfb_mf_taps: '[]'
    ss_sps: sps
    ss_ted_gain: '1.0'
    ss_ted_type: digital.TED_MUELLER_AND_MULLER
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: n_bit
    bw: '5000'
    coefficients: second_order
    freq_central: '10000'
    samp_rate: samp_rate
  states: {}
- name: ecss_signal_search_fft_hier_0
  id: ecss_signal_search_fft_hier
  parameters:
    average: 'False'
    bandwidth: '5000'
    decimation: '1'
    enable: ss
    fftsize: 1024*16
    freq_central: '10000'
    freq_cutoff: '100.0'
    samp_rate: samp_rate
    threshold: '10.0'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: flaress_null_sink_0
  id: flaress_null_sink
  parameters:
    bus_conns: '[[0,],]'
    num_inputs: '1'
    type: s64
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (2,0,2,3)
    name: Input Signal Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (5,0,1,3)
    label1: Freq
    name: PLL Frequency Output
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (4,0,1,3)
    label1: Frequency
    name: PLL Phase Error Output
    size: '1024'
    srate: samp_rate
    type: float
    yunit: Time
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: (8,0,2,3)
    label1: ''
    name: Demodulator Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_0, '0', ecss_agc_xx_0, '0']
- [ecss_agc_xx_0, '0', ecss_signal_search_fft_hier_0, '0']
- [ecss_demodulator_0, '0', blocks_char_to_float_0, '0']
- [ecss_demodulator_0, '0', blocks_file_sink_0, '0']
- [ecss_pll_0, '0', blocks_null_sink_0, '0']
- [ecss_pll_0, '1', qtgui_number_sink_0, '0']
- [ecss_pll_0, '2', ecss_demodulator_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']
- [ecss_pll_0, '3', flaress_null_sink_0, '0']
- [ecss_signal_search_fft_hier_0, '0', blocks_tag_debug_0, '0']
- [ecss_signal_search_fft_hier_0, '0', ecss_pll_0, '0']

metadata:
  file_format: 1
