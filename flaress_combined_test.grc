options:
  parameters:
    generate_options: qt_gui
    id: flaress_combined_test
    output_language: python
    title: FLareSS combined test
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: coeff
  id: variables_loop_filter
  parameters:
    damping_2: '0.707'
    damping_3: '0.707'
    epsilon: '0'
    index_m_3: '5'
    natural_freq_2: '100'
    natural_freq_3: '10'
    samp_rate: samp_rate
  states: {}
- name: cof
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1)
    label: LPF cut-off frequency
    min_len: '50'
    orient: Qt.Horizontal
    start: '10.0'
    step: '100.0'
    stop: '10000.0'
    value: '10.0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,2)
    label: Frequency offset Channel
    min_len: '50'
    orient: Qt.Horizontal
    start: '0.0'
    step: '100'
    stop: '10000.0'
    value: '0.0'
  states: {state: disabled}
- name: n_bit
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: PLL N bits
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '4'
    step: '1'
    stop: '52'
    value: '38'
  states: {}
- name: n_bit_0
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: PLL N bits
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '4'
    step: '1'
    stop: '52'
    value: '38'
  states: {state: disabled}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1)
    label: Noise Channel
    min_len: '50'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.05'
    stop: '10.0'
    value: '0.0'
  states: {state: disabled}
- name: order
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,0)
    label: PLL order
    num_opts: '2'
    option1: '3'
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: reset
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,1)
    label: Coherency Reset
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ss
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,2)
    label: Signal Search Enable
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: tw
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,2)
    label: LPF Transition Width
    min_len: '50'
    orient: Qt.Horizontal
    start: '10.0'
    step: '100.0'
    stop: '10000.0'
    value: '10'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/mod_signal_output.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /data/andrej/git/esa/Flowgraphs/files/CADU.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /data/andrej/git/esa/Flowgraphs/files/Convolutionally_encoded_CADU.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/8/2
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: ecss_agc_0
  id: ecss_agc
  parameters:
    initial_gain: '1.0'
    maximum_gain: '65536.0'
    reference: '1.0'
    samp_rate: samp_rate
    settling_time: '10.0'
  states: {}
- name: ecss_coherent_phase_modulator_0
  id: ecss_coherent_phase_modulator
  parameters:
    N: n_bit
    n_inputs: '1'
  states: {}
- name: ecss_gain_phase_accumulator_0
  id: ecss_gain_phase_accumulator
  parameters:
    downlink: '240'
    rst: reset
    uplink: '221'
  states: {}
- name: ecss_modulator_0
  id: ecss_modulator
  parameters:
    bit_rate: bit_rate
    freq_sub: '16000'
    k: '7'
    num_taps: ' int(samp_rate/11)'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    roll_off: '0.35'
    samp_rate: samp_rate
    sel_convolutional: '1'
    sel_encoder: '0'
    sel_srrc: '0'
    sine: 'True'
    state_start: '0'
  states: {}
- name: ecss_phase_converter_0
  id: ecss_phase_converter
  parameters:
    N: n_bit
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: n_bit
    bw: '5000'
    coefficients: coeff
    freq_central: '10000'
    order: order
    samp_rate: samp_rate
  states: {}
- name: ecss_signal_search_fft_hier_0
  id: ecss_signal_search_fft_hier
  parameters:
    average: 'False'
    bandwidth: '5000'
    decimation: '1'
    enable: ss
    fftsize: 1024*16
    freq_central: '10000'
    freq_cutoff: '100.0'
    samp_rate: samp_rate
    threshold: '10.0'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: flaress_selector_0
  id: flaress_selector
  parameters:
    n_inputs: '2'
    n_outputs: '1'
    select: '0'
    type: byte
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cof
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: 1024*4
    grid: 'True'
    gui_hint: (2,0,2,3)
    name: Input Signal Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024 '
    grid: 'True'
    gui_hint: (7,0,2,3)
    name: Output Signal Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0, '0', flaress_selector_0, '0']
- [blocks_file_source_0_0, '0', flaress_selector_0, '1']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_0_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', ecss_modulator_0, '0']
- [channels_channel_model_0, '0', ecss_agc_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [ecss_agc_0, '0', ecss_signal_search_fft_hier_0, '0']
- [ecss_coherent_phase_modulator_0, '0', blocks_file_sink_0, '0']
- [ecss_coherent_phase_modulator_0, '0', qtgui_freq_sink_x_0_0, '0']
- [ecss_gain_phase_accumulator_0, '0', ecss_coherent_phase_modulator_0, '0']
- [ecss_modulator_0, '0', low_pass_filter_0, '0']
- [ecss_phase_converter_0, '0', blocks_null_sink_0, '0']
- [ecss_phase_converter_0, async_out, ecss_coherent_phase_modulator_0, async_in]
- [ecss_pll_0, '0', blocks_null_sink_1, '0']
- [ecss_pll_0, '1', blocks_null_sink_3, '0']
- [ecss_pll_0, '2', blocks_null_sink_2, '0']
- [ecss_pll_0, '3', ecss_gain_phase_accumulator_0, '0']
- [ecss_signal_search_fft_hier_0, '0', ecss_pll_0, '0']
- [flaress_selector_0, '0', blocks_throttle_0, '0']
- [low_pass_filter_0, '0', ecss_phase_converter_0, '0']

metadata:
  file_format: 1
