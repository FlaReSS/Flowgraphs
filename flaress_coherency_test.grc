<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>flaress_coherency_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variables_loop_filter</key>
<param><key>id</key><value>coeff</value></param>
<param><key>damping_2</key><value>0.707</value></param>
<param><key>damping_3</key><value>0.707</value></param>
<param><key>epsilon</key><value>0</value></param>
<param><key>index_m_3</key><value>5</value></param>
<param><key>natural_freq_2</key><value>100</value></param>
<param><key>natural_freq_3</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>gui_hint</key><value>(1,2)</value></param>
<param><key>label</key><value>Frequency offset Channel</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>10000.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>n_bit</value></param>
<param><key>value</key><value>38</value></param>
<param><key>gui_hint</key><value>(1,0)</value></param>
<param><key>label</key><value>PLL N bits</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>4</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>52</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>gui_hint</key><value>(1,1)</value></param>
<param><key>label</key><value>Noise Channel</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>10.0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>order</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>(0,0)</value></param>
<param><key>label</key><value>PLL order</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>2</value></param>
<param><key>option1</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>reset</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>(0,1)</value></param>
<param><key>label0</key><value>False</value></param>
<param><key>label1</key><value>True</value></param>
<param><key>label</key><value>Coherency Reset</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>False</value></param>
<param><key>option1</key><value>True</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ss</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>(0,2)</value></param>
<param><key>label0</key><value>False</value></param>
<param><key>label1</key><value>True</value></param>
<param><key>label</key><value>Signal Search Enable</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>False</value></param>
<param><key>option1</key><value>True</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/mnt/c/Users/amir/WSL/grc/FlowGraps/FlaReSS/files/sw150kHz_swr10kHz-s_tc4kbps_mi1.0.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>ecss_agc</key>
<param><key>id</key><value>ecss_agc_0</value></param>
<param><key>initial_gain</key><value>1.0</value></param>
<param><key>maximum_gain</key><value>65536.0</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>settling_time</key><value>10.0</value></param>
</block>
<block>
<key>ecss_coherent_phase_modulator</key>
<param><key>id</key><value>ecss_coherent_phase_modulator_0</value></param>
<param><key>N</key><value>n_bit</value></param>
<param><key>n_inputs</key><value>1</value></param>
</block>
<block>
<key>ecss_gain_phase_accumulator</key>
<param><key>id</key><value>ecss_gain_phase_accumulator_0</value></param>
<param><key>rst</key><value>reset</value></param>
<param><key>downlink</key><value>240</value></param>
<param><key>uplink</key><value>221</value></param>
</block>
<block>
<key>ecss_pll</key>
<param><key>id</key><value>ecss_pll_0</value></param>
<param><key>bw</key><value>5000</value></param>
<param><key>coefficients</key><value>coeff</value></param>
<param><key>freq_central</key><value>10000</value></param>
<param><key>N</key><value>n_bit</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>order</key><value>order</value></param>
</block>
<block>
<key>ecss_signal_search_fft_hier</key>
<param><key>id</key><value>ecss_signal_search_fft_hier_0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>bandwidth</key><value>5000</value></param>
<param><key>freq_central</key><value>10000</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>enable</key><value>ss</value></param>
<param><key>fftsize</key><value>1024*16</value></param>
<param><key>freq_cutoff</key><value>100.0</value></param>
<param><key>threshold</key><value>10.0</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>(2,0,2,3)</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Input Signal Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>(6,0,2,3)</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Coherent Phase Modulator Output</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>(5,0,1,3)</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Freq</value></param>
<param><key>name</key><value>PLL Frequency Output</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>(4,0,1,3)</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Frequency</value></param>
<param><key>name</key><value>PLL Phase Error Output</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>yunit</key><value>Time</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>ecss_agc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_agc_0</source_block_id><sink_block_id>ecss_signal_search_fft_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_coherent_phase_modulator_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_gain_phase_accumulator_0</source_block_id><sink_block_id>ecss_coherent_phase_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_pll_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_pll_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_pll_0</source_block_id><sink_block_id>ecss_gain_phase_accumulator_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_pll_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_signal_search_fft_hier_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ecss_signal_search_fft_hier_0</source_block_id><sink_block_id>ecss_pll_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
