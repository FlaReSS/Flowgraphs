options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: flaress_coherency_test
    output_language: python
  states: {}

blocks:
- name: coeff
  id: variables_loop_filter
  parameters:
    damping_2: '0.707'
    damping_3: '0.707'
    epsilon: '0'
    index_m_3: '5'
    natural_freq_2: '100'
    natural_freq_3: '10'
    samp_rate: samp_rate
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,2)
    label: Frequency offset Channel
    min_len: '50'
    orient: Qt.Horizontal
    start: '0.0'
    step: '100'
    stop: '10000.0'
    value: '0.0'
  states: {}
- name: n_bit
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: PLL N bits
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '4'
    step: '1'
    stop: '52'
    value: '38'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1)
    label: Noise Channel
    min_len: '50'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.05'
    stop: '10.0'
    value: '0.0'
  states: {}
- name: order
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,0)
    label: PLL order
    num_opts: '2'
    option1: '3'
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: reset
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,1)
    label: Coherency Reset
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ss
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,2)
    label: Signal Search Enable
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /data/andrej/git/esa/Flowgraphs/files/CADU.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: ecss_agc_0
  id: ecss_agc
  parameters:
    initial_gain: '1.0'
    maximum_gain: '65536.0'
    reference: '1.0'
    samp_rate: samp_rate
    settling_time: '10.0'
  states: {}
- name: ecss_coherent_phase_modulator_0
  id: ecss_coherent_phase_modulator
  parameters:
    N: n_bit
    n_inputs: '1'
  states: {}
- name: ecss_gain_phase_accumulator_0
  id: ecss_gain_phase_accumulator
  parameters:
    downlink: '240'
    rst: reset
    uplink: '221'
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: n_bit
    bw: '5000'
    coefficients: coeff
    freq_central: '10000'
    order: order
    samp_rate: samp_rate
  states: {}
- name: ecss_signal_search_fft_hier_0
  id: ecss_signal_search_fft_hier
  parameters:
    average: 'False'
    bandwidth: '5000'
    decimation: '1'
    enable: ss
    fftsize: 1024*16
    freq_central: '10000'
    freq_cutoff: '100.0'
    samp_rate: samp_rate
    threshold: '10.0'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: 1024*4
    grid: 'True'
    gui_hint: (2,0,2,3)
    name: Input Signal Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: 1024*4
    grid: 'True'
    gui_hint: (6,0,2,3)
    name: Coherent Phase Modulator Output
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (5,0,1,3)
    label1: Freq
    name: PLL Frequency Output
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (4,0,1,3)
    label1: Frequency
    name: PLL Phase Error Output
    size: '1024'
    srate: samp_rate
    type: float
    yunit: Time
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', ecss_agc_0, '0']
- [ecss_agc_0, '0', ecss_signal_search_fft_hier_0, '0']
- [ecss_coherent_phase_modulator_0, '0', qtgui_freq_sink_x_0_1, '0']
- [ecss_gain_phase_accumulator_0, '0', ecss_coherent_phase_modulator_0, '0']
- [ecss_pll_0, '0', blocks_null_sink_0, '0']
- [ecss_pll_0, '1', qtgui_number_sink_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']
- [ecss_pll_0, '3', ecss_gain_phase_accumulator_0, '0']
- [ecss_signal_search_fft_hier_0, '0', blocks_tag_debug_0, '0']
- [ecss_signal_search_fft_hier_0, '0', ecss_pll_0, '0']

metadata:
  file_format: 1
