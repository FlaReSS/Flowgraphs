options:
  parameters:
    author: arode
    generate_options: qt_gui
    id: rx_cortex
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: if_freq
  id: variable
  parameters:
    value: '70000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: if_freq
    fftsize: '4096'
    nconnections: '2'
    type: complex
    update_time: '0'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: if_freq
    center_freq1: if_freq
    dc_offs_enb0: '"1"'
    dc_offs_enb1: '"1"'
    dev_addr: '"addr=192.168.30.2,second_addr=192.168.40.2"'
    dev_args: '""'
    gain0: '1'
    gain1: '1'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'True'
    norm_gain1: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
