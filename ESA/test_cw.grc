options:
  parameters:
    generate_options: qt_gui
    id: test_cw
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 435e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 435e6
    fftsize: '4096'
    label1: Channel 0
    label2: Channel 1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 0"'
    size: 1024*100
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.1'
    ymax: '0.8'
    ymin: '-0.8'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 1"'
    size: 1024*100
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.1'
    ymax: '0.8'
    ymin: '-0.8'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: center_freq
    center_freq1: center_freq
    dc_offs_enb0: '"on"'
    dc_offs_enb1: '"on"'
    dev_addr: '"addr=192.168.30.2,second_addr=192.168.40.2"'
    dev_args: '""'
    gain0: '15'
    gain1: '15'
    iq_imbal_enb0: '"1"'
    iq_imbal_enb1: '"1"'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
