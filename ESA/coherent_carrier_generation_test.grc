options:
  parameters:
    author: Stefano Speretta
    generate_options: qt_gui
    id: coherent_carrier_generation_test
    output_language: python
    title: Coherent Carrier Generation_test
  states: {}

blocks:
- name: coherency
  id: variable_qtgui_chooser
  parameters:
    label: Coherency
    label0: Open Loop
    label1: Coherent
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    orient: Qt.Horizontal
    start: '-20e3'
    step: '100'
    stop: 20e3
    value: '11000'
  states: {}
- name: loop_filter_2nd_order
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '800'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.6'
  states: {}
- name: modulation_coeff_down
  id: variable_qtgui_range
  parameters:
    label: Downlink Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: modulation_coeff_up
  id: variable_qtgui_range
  parameters:
    label: Uplink Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: sweep_range
  id: variable_qtgui_range
  parameters:
    label: Sweep Range (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: 1e3
    stop: 50e3
    value: '8000'
  states: {}
- name: sweep_rate
  id: variable_qtgui_range
  parameters:
    label: Sweep rate (Hz/s)
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: 50e3
    value: '2000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(-snr/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: modulation_coeff_up
    freq: subcarrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2_1
  id: analog_sig_source_x
  parameters:
    amp: 2*3.14159265359*sweep_range
    freq: 0 if sweep_range == 0 else sweep_rate/sweep_range
    offset: 2*3.14159265359*frequency
    phase: '-3.14159265359'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '1'
  states: {}
- name: ecss_signal_search_goertzel_0
  id: ecss_signal_search_goertzel
  parameters:
    average: 'False'
    bandwidth: '3000'
    enable: 'True'
    freq_central: '15000'
    freq_cutoff: '100'
    samp_rate: samp_rate
    threshold: '10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Input
    label2: Output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
    ymin: '-90'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: '0'
    center_freq1: 70e6
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_2_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_2_1, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_1, '0', ecss_signal_search_goertzel_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', ecss_signal_search_goertzel_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_throttle_0_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [ecss_signal_search_goertzel_0, '0', blocks_tag_debug_1, '0']
- [ecss_signal_search_goertzel_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', blocks_null_sink_2, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
